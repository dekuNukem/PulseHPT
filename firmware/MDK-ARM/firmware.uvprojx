# Keil uVision project firmware.uvprojx, settings and files
target firmware (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F042F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: firmware +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32f042x6.s
  group Application/User/Core
    ../Core/Src/: ssd1306.c ssd1306_fonts.c main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
    ../Core/Inc/: ssd1306.h ssd1306_fonts.h ssd1306_conf.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
